# Keil uVision project DAC_Wave.uvprojx, settings and files
target DAC_Wave (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: DAC_Wave +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H750xx
  c include: ..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport;..\Project;..\STM32H7xx_HAL_Driver\Inc;..\User\delay;..\User\LED;..\User\KEY;..\User\usart;..\User\LCD;..\User\stm32h7xx_it;..\User\system;..\User\DAC;..\User\TIMER;..\User\Sinex_ware;..\User\ad7606b;..\User\gpio;..\User\FFT;..\STM32H7xx_HAL_Driver\Src;..\User\dac8830;..\User\spi;..\User\W25QXX;..\User\qspi;..\User\NORFLASH;..\User\18b20;..\User\ADS131A04;..\User\identity_flash;..\User\runtime_flash;..\User\calib_flash;..\User\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group main
    ./: main.c EIS_Measure.c EIS_Measure.h
    ../User/stm32h7xx_it/: stm32h7xx_it.c
    ../CMSIS/DeviceSupport/: system_stm32h7xx.c
  group User
    ../User/LED/: led.c
    ../User/delay/: delay.c
    ../User/KEY/: key.c
    ../User/usart/: usart.c
    ../User/system/: system.c
    ../User/TIMER/: timer.c
    ../User/DAC/: dac.c
    ./: SineWave.c SineWave.h watchdog.c watchdog.h fdcan.c fdcan.h digital_lock_in.c digital_lock_in.h config_flash.h config_flash.c MOS_Controller.c MOS_Controller.h AD620_GainCtrl.h AD620_GainCtrl.c Potentiometer_Calibration.h Potentiometer_Calibration.c DAC_Linear_Calibration.h DAC_Linear_Calibration.c current_acquisition_calibrator.c current_acquisition_calibrator.h current_excitation_calibrator.c current_excitation_calibrator.h global_command.c global_command.h parse_command.c parse_command.h SYS_protection.c SYS_protection.h
    ../User/ad7606b/: AD7606.c
    ../User/dac8830/: dac8830.c
    ../User/spi/: spi.c
    ../User/W25QXX/: w25qxx.c
    ../User/NORFLASH/: norflash.c norflash_ex.c
    ../User/18b20/: 18B20.c
    ../User/qspi/: qspi.c qspi.h
    ../User/identity_flash/: identity_flash.c identity_flash.h
    ../User/runtime_flash/: runtime_flash.c runtime_flash.h
    ../User/calib_flash/: calib_flash.c calib_flash.h
    ../User/ADS131A04/: ADS131A04.c ADS131A04.h
    ../User/FFT/: fft_analyzer.c fft_analyzer.h
    ../User/ADC/: adc.c adc.h
  group HAL_Driver
    ../STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c
  group CMSIS
    ../CMSIS/CoreSupport/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm7.h
    ../CMSIS/DeviceSupport/: startup_stm32h750xx.s
